# Keil uVision project test002.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test002 +hex
  c flags: Optim=1
  c misc: --gnu
  c include: ..\..\Lib\STM32F10x_StdPeriph_Driver\inc;..\..\Lib\STM32F10x_StdPeriph_Driver\src;..\..\Lib\CMSIS\CM3\CoreSupport;..\..\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\..\User;..\..\User\dmp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../../User/: stm32f10x_conf.h stm32f10x_it.c main.cpp delay.c i2c_cpp.cpp uart_cpp.cpp Ultrasonic.c PWM_out.c LED.c
    ../../User/dmp/: inv_mpu_dmp_motion_driver.c DMP.c inv_mpu.c
  group StdPeriph_Driver350
    ../../Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup
    ../../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../../Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
